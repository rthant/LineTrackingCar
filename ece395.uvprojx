# Keil uVision project ece395.uvprojx, settings and files
target KL25Z - PE Micro - Ram (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: MKL25Z128xxx4 Freescale
  pack: Keil.Kinetis_KLxx_DFP.1.14.0
  cpu: IROM(0x00000000,0x20000) IRAM(0x1FFFF000,0x4000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: kl25z
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: CLOCK_SETUP=1
  asm misc: --predefine "__MICROLIB SETL {TRUE}"
  memory RVCT4: ROM 0x1ffff000 size 0x1000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group User Code
    ./: main.c asm_main.s
target Cortex-M0+ (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM0P ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: kl25z
  c flags: Optim=1 v6Lang=1 v6LangP=1
  asm misc: --predefine "__MICROLIB SETL {TRUE}"
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
target Cortex-M3 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.5.3.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: kl25z
  c flags: Optim=1 v6Lang=1 v6LangP=1
  asm misc: --predefine "__MICROLIB SETL {TRUE}"
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
software components: CMSIS:CORE 4.3.0, Device:Startup 1.0.1, Device:Startup 1.0.1, Device:Startup 2.5.0
